Commit message: 2

File: a1_motor/a1_motor.urdf (robot description, URDF)
Before this commit: robot a1_motor, 4 links, 3 joints
Links:
- link link2: mass 0.1 -> 0.05
Joints:
- joint joint2: origin xyz=-0.2 0.0075 0 rpy=0.0 0.0 0.0 -> xyz=0 0.0075 -0.2 rpy=0.0 0.0 0.0
